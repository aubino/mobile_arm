Commit message: Modified robot tolerance to go to goal more perfectly

File: mobile_manipulator/urdf/camera.urdf (robot description, URDF)
Before this commit: robot up_camera, 2 links, 1 joints
Joints:
- joint up_camera_joint: origin xyz=0 0 0 rpy=0 1.57 0 -> xyz=0 0 0 rpy=0 1.5707 0
